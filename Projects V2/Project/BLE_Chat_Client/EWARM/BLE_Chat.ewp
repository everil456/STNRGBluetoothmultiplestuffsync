# IAR project BLE_Chat.ewp, settings and files
configuration Client (ARM)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; CLIENT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\I2C\inc; ..\..\..\platform\STM32L1XX\Libraries\LIS3DH\inc; ..\..\..\platform\STM32L1XX\Libraries\STLM75\inc; ..\..\..\platform\STM32L1XX\Libraries\HTS221\inc; ..\..\..\platform\STM32L1XX\Libraries\LPS25H\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Chat_Client.hex
  ILINK.IlinkOutputFile: BLE_Chat.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Server (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; SERVER=1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server.hex
configuration Server_LowerApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; SERVER=1; ST_OTA_BTL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI; ..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes; ..\..\..\platform\STM32L1XX; ..\..\..\platform\STM32L1XX\Libraries; ..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\platform\STM32L1XX\Libraries\I2C\inc; ..\..\..\platform\STM32L1XX\Libraries\LIS3DH\inc; ..\..\..\platform\STM32L1XX\Libraries\STLM75\inc; ..\..\..\platform\STM32L1XX\Libraries\HTS221\inc; ..\..\..\platform\STM32L1XX\Libraries\LPS25H\inc; ..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\inc; ..\..\..\Bluetooth LE\BlueNRG_OTA\inc
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server_LowerApp_OTA.hex
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1
configuration Server_HigherApp_OTA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; SERVER=1; ST_OTA_BTL; HIGHER_APP
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server_HigherApp_OTA.bin
  ILINK.IlinkConfigDefines: ST_OTA_BTL=1; HIGHER_APP=1
configuration Server_OTA_Basic (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; SERVER=1; ST_OTA_BASIC_APPLICATION
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Server_OTA_Basic.bin
  ILINK.IlinkConfigDefines: ST_OTA_BASIC_APPLICATION=1
configuration Client_throughput (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; CLIENT=1; THROUGHPUT_TEST=1; ENABLE_SPI_FIX=0
configuration Server_throughput (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; SYSCLK_FREQ_HSI_32MHz; ENABLE_USB; ENABLE_USB_PRINTF; SERVER=1; THROUGHPUT_TEST=1; ENABLE_SPI_FIX=0
  OBJCOPY.OOCOutputFile: BLE_Chat_Server.hex
  group blestack/hci
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/: hci.c
  group blestack/hci/controller
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
  group blestack/includes
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/includes/: ble_status.h bluenrg_aci.h bluenrg_aci_const.h bluenrg_gap_aci.h bluenrg_gatt_aci.h bluenrg_hal_aci.h bluenrg_l2cap_aci.h bluenrg_updater_aci.h clock.h compiler.h gap.h gatt_server.h gp_timer.h hal.h hal_types.h hci.h hci_const.h link_layer.h list.h osal.h sm.h
  group blestack/utils
    ../../../Bluetooth LE/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group EWARM
    ../../../platform/STM32L1XX/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group OTA
    ../../../Bluetooth LE/BlueNRG_OTA/src/: btl.c
  group platform/STM32L1XX
    ../../../platform/STM32L1XX/: clock.c hal.c osal.c
  group Platforms_Layers
    ../../../platform/STM32L1XX/Libraries/SDK_Eval_STM32L/src/: SDK_EVAL_Button.c SDK_EVAL_Config.c SDK_EVAL_Io.c SDK_EVAL_Led.c SDK_EVAL_Spi_Driver.c
  group STM32L1xx_StdPeriph_Driver
    ../../../platform/STM32L1XX/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_systick.c stm32l1xx_tim.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../platform/STM32L1XX/Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: BLE_Chat_main.c BLE_Chat_main_OTA.c chat.c flags.c gatt_db.c hw_config.c led.c push_button.c slave_devices.c stm32l1xx_it.c timer.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
