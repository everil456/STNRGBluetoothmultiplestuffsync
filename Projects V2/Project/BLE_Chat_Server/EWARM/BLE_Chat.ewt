<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Client</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Server</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Server_LowerApp_OTA</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Server_HigherApp_OTA</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Server_OTA_Basic</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Client_throughput</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Server_throughput</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>blestack</name>
    <group>
      <name>hci</name>
      <group>
        <name>controller</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_gap_aci.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_gatt_aci.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_hal_aci.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_IFR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_l2cap_aci.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_updater_aci.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\controller\bluenrg_utils.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\hci\hci.c</name>
      </file>
    </group>
    <group>
      <name>includes</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\ble_status.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_aci_const.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_gap_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_gatt_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_hal_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_l2cap_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\bluenrg_updater_aci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\clock.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\compiler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\gap.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\gatt_server.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\gp_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\hal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\hal_types.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\hci.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\hci_const.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\link_layer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\list.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\osal.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\includes\sm.h</name>
      </file>
    </group>
    <group>
      <name>utils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\utils\gp_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bluetooth LE\SimpleBlueNRG_HCI\utils\list.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\src\system_stm32l1xx.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx\startup\iar\startup_stm32l1xx_md.s</name>
    </file>
  </group>
  <group>
    <name>OTA</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Bluetooth LE\BlueNRG_OTA\src\btl.c</name>
    </file>
  </group>
  <group>
    <name>platform</name>
    <group>
      <name>STM32L1XX</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\osal.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platforms_Layers</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\src\SDK_EVAL_Button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\src\SDK_EVAL_Config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\src\SDK_EVAL_Io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\src\SDK_EVAL_Led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\SDK_Eval_STM32L\src\SDK_EVAL_Spi_Driver.c</name>
    </file>
  </group>
  <group>
    <name>STM32L1xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash_ramfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>USB-FS-Device_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_cal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_dev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\otgd_fs_pcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\platform\STM32L1XX\Libraries\STM32_USB-FS-Device_Driver\src\usb_sil.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\src\BLE_Chat_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\BLE_Chat_main_OTA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\chat.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\gatt_db.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\push_button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stm32l1xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_endp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_istr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_prop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_pwr.c</name>
    </file>
  </group>
</project>


